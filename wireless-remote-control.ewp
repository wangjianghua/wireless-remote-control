# IAR project wireless-remote-control.ewp, settings and files
configuration Debug (M16C, debug)
  General.GData16HeapSize: 1024
  General.GFarHeapSize: 1024
  General.GData20HeapSize: 1024
  General.GStackSize: 256
  General.GIStackSize: 64
  General.OGChipSelectMenu: R5F211B4 R5F211B4
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICCM16C.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f211b4.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: M16CGEN Generic M16C
  XLINK.XclFile: lnk0t.xcl
  group (top)
    src/: aes_lib_tiny.c clock.c flash.c intp.c isr.c key.c lvi.c port.c rf.c spi.c sys_event.c sys_main.c sys_multi.c timer.c uart.c wdt.c
